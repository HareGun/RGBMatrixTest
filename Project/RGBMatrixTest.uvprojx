# Keil uVision project RGBMatrixTest.uvprojx, settings and files
target STM32F103RCT6 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IRAM(0x20000000,0x0000C000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: RGBMatrixTest +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\Libraries\CMSIS\CM3\CoreSupport;..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\Libraries\SEEGER\SystemView\Src\SEGGER;..\Libraries\SEEGER\SystemView\Src\Config;..\Libraries\SEEGER\SystemView\Src\Sample\FreeRTOSV9;..\Libraries\SEEGER\SystemView\Src\Sample\FreeRTOSV9\Config;..\Libraries\FreeRTOS\include;..\Libraries\FreeRTOS\portable\RVDS\ARM_CM3;..\User;..\Drivers;..\Devices;..\Apps;..\Tasks
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group User
    ../User/: main.c stm32f10x_it.c typedefs.h user_common.h FreeRTOSConfig.h
  group Tasks
    ../Tasks/: SystemInit_Tasks.c Key_Task.c Control_Task.c
  group Apps
    ../Apps/: Filter.c RGB_matrixGFX.c matrix_app.c glcdfont.c
  group Devices
    ../Devices/: M3508_Motor.c LED.c key.c SK6812_drv.c
  group Drivers
    ../Drivers/: delay.c GPIO.c NVIC.c USART.c TIM.c CAN.c Flash.c I2C_SW.c I2C_HW.c
  group FreeRTOS\Source
    ../Libraries/FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group FreeRTOS\Portable
    ../Libraries/FreeRTOS/portable/RVDS/ARM_CM3/: port.c portmacro.h
    ../Libraries/FreeRTOS/portable/MemMang/: heap_4.c
  group Libraries\StdPeriph
    ../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c stm32f10x_adc.c
  group SEGGER\SystemView
    ../Libraries/SEEGER/SystemView/Src/Sample/FreeRTOSV9/: SEGGER_SYSVIEW_FreeRTOS.c
    ../Libraries/SEEGER/SystemView/Src/Sample/FreeRTOSV9/Config/: SEGGER_SYSVIEW_Config_FreeRTOS.c
    ../Libraries/SEEGER/SystemView/Src/SEGGER/: SEGGER_RTT.c SEGGER_SYSVIEW.c
  group SEGGER\RTT
    ../Libraries/SEEGER/RTT/RTT/: SEGGER_RTT.c SEGGER_RTT.h SEGGER_RTT_Conf.h SEGGER_RTT_printf.c
  group startup
    ../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
    ../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_hd.s
